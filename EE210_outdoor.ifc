Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
Time: Wed Aug 12 17:21:11 2020
Author: at3107
Written by: PTC Creo 1.0
Made in: PTC

# IfcProject, Default Project
LongName: Project Status; Phase: Project Status

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Part, EE210_O
In: Default Storey
PTC_Identity Data - DEVICENAME: Humidity and Temperature Sensor for Outdoor and Meteorological Applications; MEASURAND1: Relative Humidity; Working range 0…100 % r.h.; MEASURAND2: Temperature; Measuring range -40...60 °C (-40...140 °F); OUTPUT1: Analogue voltage / current; 0-10 V / 4-20 mA; SUPPLY: 24 V AC ±20 % / 15-35 V DC; ENCLOSUREMATERIAL: Polycarbonate / UL94V-0 approved; ENCLOSUREDIMENSIONS: WxHxD = 80x80x37.2 mm (3.15x3.15x1.46"); ENCLOSUREDESIGNSTANDARD: Cover: light grey RAL7035; housing: silver grey RAL7001; VOLUME: 251063; SURFACE_AREA: 27481.5; MASS: 251063; DENSITY: 1; CENTRE_OF_GRAVITY_X: 0; CENTRE_OF_GRAVITY_Y: 9.225; CENTRE_OF_GRAVITY_Z: 1.9756
